Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-05-30T14:18:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 30 14:18:24 2023 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\d1915630-a091-4da6-a74c-f0cddfb5b80f\60f57a0f-6bea-4329-b0d6-8afb7aaa517b\ifc * Database version: 5507 * Database creation date: Tue May 30 14:18:22 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 30 14:18:23 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 30 14:18:23 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 1814FG Washbasin faucet with washing machine valve, 1814FG(2022):1814FG Washbasin faucet with washing machine valve:450614
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 173.309 mm; FaucetNominalHeight: 168.542 mm; FaucetNominalWidth: 53.7375 mm; HandShowerNominalDepth: 64.3328 mm; HandShowerNominalHeight: 296.661 mm; HandShowerNominalWidth: 49.2648 mm; InletConnectionSize: 10 mm
Type - General - Author: BIMStone; BIMObjectName: 1814FG(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - EAN Number: 6414150102851; ETIM Class Number: EC011328 Washbasin mixing tap; LVI Number: 6110461; Sales Package dimensions (LxWxH): 590 x 290 x 65; STF Certificate: EUFI29-20000935-TH1; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/182977_1814FG_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL STF: http://static.oras.com/STF/1814FG; URL UWL: http://static.oras.com/UWL/1814FG
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/1814FG; 3D View: https://static.oras.com/AR/1814FG; Catalog Drawing URL: http://static.oras.com/catdrw/1814FG; Dimension Drawing URL: http://static.oras.com/dimdrw/1814FG; FDV Document URL: http://www.oras.com/datasheet/1814FG/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1814FG; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/1814FG; Interactive AR View URL: https://static.oras.com/AR/1814FG; Manufacturer: Oras; Market: International;Finland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/1814FG; Model: 1814FG Washbasin faucet with washing machine valve; Name_en: 1814FG Washbasin faucet with washing machine valve; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 1814FG; Product Family: Oras Vega; Product Image URL: http://static.oras.com/image/1814FG; Product URL: http://static.oras.com/1814FG; Technical DataSheet URL: http://www.oras.com/datasheet/1814FG/en; Type Name: 1814FG Washbasin faucet with washing machine valve; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: 3S-installation system for safe and simple mounting; Aerator: Standard aerator; Connection: Flexible inlet pipes; Connection Size: G3/8; Dishwasher Valve: Mechanic stop valve for external equipment; Eco Flow At 300kPa: 0.00423776 m3/s; Flow Rate At 300kPa: 0.00494405 m3/s; Hand Shower: Bidetta hand shower; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols;Eco feature for water flow; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Pressure Loss With Flow 01ls: 160000 Pa; Shower Parts: Shower holder;Shower hose (1500 mm); Shower Spray Number: 1 shower spray; Spout Projection: 133 mm; Spout Swivel Range: 120° (40° - 80°); Spout Type: Swivel spout; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1814FG(2022); Features: Single-lever;Bidetta;Dishwasher valve; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1814FG; Name: 1814FG Washbasin faucet with washing machine valve; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet: 55x175x170 mm / Hand shower: 50x65x295 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 1814FG Washbasin faucet with washing machine valve; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1814FG; Manufacturer: Oras
Pset_ProductRequirements - Name: 1814FG Washbasin faucet with washing machine valve; Category: Plumbing Fixtures
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0855489 m2; Volume: 0.00251459 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1814FG(2022): 1814FG Washbasin faucet with washing machine valve; Family and Type: 1814FG(2022): 1814FG Washbasin faucet with washing machine valve; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1814FG(2022): 1814FG Washbasin faucet with washing machine valve; Type Id: 1814FG(2022): 1814FG Washbasin faucet with washing machine valve; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
